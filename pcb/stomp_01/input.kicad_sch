File: pcb/stomp_01/input.kicad_sch (KiCad schematic)
At the start: 30 parts, among them U2 TL072

Commit message: looking nice
Parts:
- renumbered U2 to U3
